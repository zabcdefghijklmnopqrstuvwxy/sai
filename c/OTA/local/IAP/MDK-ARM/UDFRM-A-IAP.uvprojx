# Keil uVision project UDFRM-A-IAP.uvprojx, settings and files
target UDFRM-A-IAP-407 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: UDFRM-D-LED-407 +hex (library)
  AfterMake: ..\cpp.bat "#L"  "@L.lib"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_F4XX_HAL
  c include: ../Inc;../MDK-ARM;../../Release/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group UDFRM-A-IAP
    ../Src/: drv_flash.c iap.c sftp.c
  group TEST
    ../Test/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
target UDFRM-A-IAP-103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UDFRM-D-LED-103 +hex (library)
  AfterMake: ..\cpp.bat "#L"  "@L.lib"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,USE_F1XX_HAL
  c include: ..\Inc;..\MDK-ARM;../../Release/Inc;..\..\..\UDFRM-HAL-103\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\UDFRM-HAL-103\Release\Inc;..\..\..\UDFRM-HAL-103\Release\Inc\Legacy;..\..\..\UDFRM-HAL-103\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target UDFRM-A-IAP-test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: UDFRM-D-LED-407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_F4XX_HAL
  c include: ../Inc;../MDK-ARM;../../Release/Inc;..\Test\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.1.2, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:Startup 1.0.0, Device:Startup 2.6.0
